# Keil uVision project Skeleton_Bootloader.uvprojx, settings and files
target Skeleton_Bootloader (6160000::V6.16::ARMCLANG)
  device: STM32WLE5JBIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: Skeleton_Bootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WLE5xx, _USE_STDLIB
  c include: ../Core/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Drivers/CMSIS/Include;../CustomFiles/CRC/Inc;../CustomFiles/EEPROM_Structure/Inc;../CustomFiles/Flash_Functions/Inc;../CustomFiles/Startup/Inc;../CustomFiles;..\CustomFiles\Routines\Inc;..\ExternalLibraries\safestringlib\include;..\CustomFiles\Callbacks\Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group CustomFiles/CRC
    ../CustomFiles/CRC/Src/: r_crc.c
  group CustomFiles/EEPROM_Structure
    ../CustomFiles/EEPROM_Structure/Src/: r_eeprom_structure.c
  group CustomFiles/Flash_Functions
    ../CustomFiles/Flash_Functions/Src/: r_flash_functions.c
  group CustomFiles/Startup
    ../CustomFiles/Startup/Src/: r_startup.c
  group CustomFiles/Routines
    ../CustomFiles/Routines/Src/: r_routine_update.c
  group ExternalLibraries/safestringlib
    ../ExternalLibraries/safestringlib/safeclib/: abort_handler_s.c ignore_handler_s.c mem_primitives_lib.c memcpy_s.c safe_mem_constraint.c memset_s.c
  group CustomFiles/Callbacks
    ../CustomFiles/Callbacks/Src/: r_uart_callback.c
software components: CMSIS:CORE 4.3.0
